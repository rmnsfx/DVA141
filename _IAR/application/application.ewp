# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21E18B Atmel ATSAML21E18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ../../Src; ../../Inc; ../../tests; ../../flash_map; ../../FreeRTOS/Source/; ../../FreeRTOS; ../../FreeRTOS/Source/include/; ../../FreeRTOS/Source/FreeRTOS-Plus-TCP/include; ../../FreeRTOS/Source/FreeRTOS-Plus-TCP/portable/Compiler/IAR/; ../../FreeRTOS/Source/portable/IAR/ARM_CM0/; ../../FreeRTOS/include; ../../FreeRTOS/include/net; ../../systems/interfaces/; ../../systems/patterns/; $PROJ_DIR$; ../../board; ../../common; ../../device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $PROJ_DIR$; ../../Inc
  OBJCOPY.OOCOutputFile: application.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: main.cpp
    ../../C/: main.ENU.projtempl
  group FreeRTOS/include
    ../../FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/portable
    ../../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group FreeRTOS/Source
    ../../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Inc
    ../../Inc/: FreeRTOSConfig.h Systems_headers.h
  group linker
    ./: flash.icf
  group Src
    ../../Src/: Device.cpp
