# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21E18B Atmel ATSAML21E18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __FREERTOS__; BOARD=USER_BOARD; ARM_MATH_CM0PLUS=true; TCC_ASYNC=true; EXTINT_CALLBACK_MODE=true; SPI_CALLBACK_MODE=true; TC_ASYNC=false; __SAML21E18B__
  ICCARM.CCIncludePath2: ../../src; ../../src/ASF; ../../src/ASF/common; ../../src/ASF/common/boards; ../../src/ASF/common/utils; ../../src/ASF/boards; ../../src/ASF/utils; ../../src/ASF/utils/interrupt; ../../src/ASF/common2; ../../src/ASF/common2/boards/user_board; ../../src/ASF/boards; ../../src/ASF/boards/user_board; ../../src/ASF/sam0; ../../src/ASF/sam0/drivers; ../../src/ASF/sam0/drivers/dma; ../../src/ASF/sam0/drivers/dma/quick_start; ../../src/ASF/sam0/drivers/extint; ../../src/ASF/sam0/drivers/extint/extint_sam_l_c; ../../src/ASF/sam0/drivers/port; ../../src/ASF/sam0/drivers/port/quick_start; ../../src/ASF/sam0/drivers/sercom; ../../src/ASF/sam0/drivers/sercom/spi; ../../src/ASF/sam0/drivers/sercom/spi/quick_start_dma; ../../src/ASF/sam0/drivers/sercom/spi/quick_start_master; ../../src/ASF/sam0/drivers/sercom/spi/quick_start_master_callback; ../../src/ASF/sam0/drivers/sercom/spi/quick_start_slave; ../../src/ASF/sam0/drivers/sercom/spi/quick_start_slave_callback; ../../src/ASF/sam0/drivers/system/; ../../src/ASF/sam0/drivers/system/clock; ../../src/ASF/sam0/drivers/system/clock/clock_saml21; ../../src/ASF/sam0/drivers/system/interrupt; ../../src/ASF/sam0/drivers/system/interrupt/system_interrupt_saml21; ../../src/ASF/sam0/drivers/system/pinmux; ../../src/ASF/sam0/drivers/system/pinmux/quick_start; ../../src/ASF/sam0/drivers/system/power; ../../src/ASF/sam0/drivers/system/power/power_sam_l; ../../src/ASF/sam0/drivers/system/reset; ../../src/ASF/sam0/drivers/system/reset/reset_sam_l; ../../src/ASF/sam0/drivers/tc; ../../src/ASF/sam0/drivers/tc/tc_sam_l_c; ../../src/ASF/sam0/drivers/tcc; ../../src/ASF/sam0/drivers/tcc/quick_start; ../../src/ASF/sam0/drivers/tcc/quick_start_buffering; ../../src/ASF/sam0/drivers/tcc/quick_start_callback; ../../src/ASF/sam0/drivers/tcc/quick_start_dma; ../../src/ASF/sam0/drivers/tcc/quick_start_faultn; ../../src/ASF/sam0/drivers/tcc/quick_start_faultx; ../../src/ASF/sam0/drivers/tcc/quick_start_timer; ../../src/ASF/sam0/utils; ../../src/ASF/sam0/utils/cmsis; ../../src/ASF/sam0/utils/cmsis/saml21; ../../src/ASF/sam0/utils/cmsis/saml21/include_b; ../../src/ASF/sam0/utils/cmsis/saml21/include_b/component; ../../src/ASF/sam0/utils/cmsis/saml21/include_b/instance; ../../src/ASF/sam0/utils/cmsis/saml21/include_b/pio; ../../src/ASF/sam0/utils/cmsis/saml21/source; ../../src/ASF/sam0/utils/cmsis/saml21/source/iar; ../../src/ASF/sam0/utils/header_files; ../../src/ASF/sam0/utils/preprocessor; ../../src/ASF/thirdparty/CMSIS/Include; ../../src/ASF/thirdparty/CMSIS/Lib; ../../src/ASF/thirdparty/freertos/freertos-9.0.0/; ../../src/ASF/thirdparty/freertos/freertos-9.0.0/Source; ../../src/ASF/thirdparty/freertos/freertos-9.0.0/Source/include; ../../src/ASF/thirdparty/freertos/freertos-9.0.0/Source/portable/IAR/ARM_CM0; ../../src/ASF/thirdparty/freertos/freertos-9.0.0/Source/portable/MemMang; ../../src/Config; ../../systems; ../../source; ../../ADXL; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: __SAML21E18B__
  AARM.AUserIncludes: $PROJ_DIR$; ../../src/Config1
  OBJCOPY.OOCOutputFile: application.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ../../: main.cpp
    ../../C/: main.ENU.projtempl
  group ADXL
    ../../ADXL/: ADXL346.c ADXL346.h
  group linker
    ./: flash.icf
  group source
    ../../source/: Axelerometr.cpp Axelerometr.h Axis.cpp Axis.h Device.cpp Device.h fs3200_bandpas_butterwort_10_1000.h fs3200_bandpas_butterwort_2_1000.h fs3200_bandpas_butterwort_5_1000.h Generator_output_signals.cpp Generator_output_signals.h iSignal.cpp iSignal.h Out_4_20.cpp Out_4_20.h Task_manager.cpp Task_manager.h Vibro_acceleration.cpp Vibro_acceleration.h
  group src
    ../../src/: asf.h
  group src/ASF/common/boards
    ../../src/ASF/common/boards/: board.h
  group src/ASF/common/utils
    ../../src/ASF/common/utils/: interrupt.h parts.h
  group src/ASF/common/utils/interrupt
    ../../src/ASF/common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group src/ASF/common2/boards/user_board
    ../../src/ASF/common2/boards/user_board/: init.c user_board.h
  group src/ASF/sam0/drivers/dma
    ../../src/ASF/sam0/drivers/dma/: dma.c dma.h dma_crc.h
  group src/ASF/sam0/drivers/dma/quick_start
    ../../src/ASF/sam0/drivers/dma/quick_start/: qs_dma_basic.h
  group src/ASF/sam0/drivers/extint
    ../../src/ASF/sam0/drivers/extint/: extint.h extint_callback.c extint_callback.h
  group src/ASF/sam0/drivers/extint/extint_sam_l_c
    ../../src/ASF/sam0/drivers/extint/extint_sam_l_c/: extint.c
  group src/ASF/sam0/drivers/port
    ../../src/ASF/sam0/drivers/port/: port.c port.h
  group src/ASF/sam0/drivers/port/quick_start
    ../../src/ASF/sam0/drivers/port/quick_start/: qs_port_basic.h
  group src/ASF/sam0/drivers/sercom
    ../../src/ASF/sam0/drivers/sercom/: sercom.c sercom.h sercom_interrupt.c sercom_interrupt.h sercom_pinout.h
  group src/ASF/sam0/drivers/sercom/spi
    ../../src/ASF/sam0/drivers/sercom/spi/: spi.c spi.h spi_interrupt.c spi_interrupt.h
  group src/ASF/sam0/drivers/sercom/spi/quick_start_dma
    ../../src/ASF/sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group src/ASF/sam0/drivers/sercom/spi/quick_start_master
    ../../src/ASF/sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group src/ASF/sam0/drivers/sercom/spi/quick_start_master_callback
    ../../src/ASF/sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group src/ASF/sam0/drivers/sercom/spi/quick_start_slave
    ../../src/ASF/sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group src/ASF/sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../src/ASF/sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group src/ASF/sam0/drivers/systems
    ../../src/ASF/sam0/drivers/system/: system.c system.h
  group src/ASF/sam0/drivers/systems/clock
    ../../src/ASF/sam0/drivers/system/clock/: clock.h gclk.h
  group src/ASF/sam0/drivers/systems/clock/clock_saml21
    ../../src/ASF/sam0/drivers/system/clock/clock_saml21/: clock.c clock_config_check.h clock_feature.h gclk.c
  group src/ASF/sam0/drivers/systems/interrupt
    ../../src/ASF/sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group src/ASF/sam0/drivers/systems/interrupt/system_interrupt_saml21
    ../../src/ASF/sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group src/ASF/sam0/drivers/systems/pinmux
    ../../src/ASF/sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group src/ASF/sam0/drivers/systems/pinmux/quick_start
    ../../src/ASF/sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group src/ASF/sam0/drivers/systems/power/power_sam_l
    ../../src/ASF/sam0/drivers/system/power/power_sam_l/: power.h
  group src/ASF/sam0/drivers/systems/reset/reset_sam_l
    ../../src/ASF/sam0/drivers/system/reset/reset_sam_l/: reset.h
  group src/ASF/sam0/drivers/tc
    ../../src/ASF/sam0/drivers/tc/: tc.h
  group src/ASF/sam0/drivers/tc/tc_sam_l_c
    ../../src/ASF/sam0/drivers/tc/tc_sam_l_c/: tc.c
  group src/ASF/sam0/drivers/tcc
    ../../src/ASF/sam0/drivers/tcc/: tcc.c tcc.h tcc_callback.c tcc_callback.h
  group src/ASF/sam0/drivers/tcc/quick_start
    ../../src/ASF/sam0/drivers/tcc/quick_start/: qs_tcc_basic.h
  group src/ASF/sam0/drivers/tcc/quick_start_buffering
    ../../src/ASF/sam0/drivers/tcc/quick_start_buffering/: qs_tcc_buffering.h
  group src/ASF/sam0/drivers/tcc/quick_start_callback
    ../../src/ASF/sam0/drivers/tcc/quick_start_callback/: qs_tcc_callback.h
  group src/ASF/sam0/drivers/tcc/quick_start_dma
    ../../src/ASF/sam0/drivers/tcc/quick_start_dma/: qs_tcc_dma.h
  group src/ASF/sam0/drivers/tcc/quick_start_faultn
    ../../src/ASF/sam0/drivers/tcc/quick_start_faultn/: qs_tcc_faultn.h
  group src/ASF/sam0/drivers/tcc/quick_start_faultx
    ../../src/ASF/sam0/drivers/tcc/quick_start_faultx/: qs_tcc_faultx.h
  group src/ASF/sam0/drivers/tcc/quick_start_timer
    ../../src/ASF/sam0/drivers/tcc/quick_start_timer/: qs_tcc_timer.h
  group src/ASF/sam0/utils/cmsis/saml21/include_b
    ../../src/ASF/sam0/utils/cmsis/saml21/include_b/: saml21.h saml21e15b.h saml21e16b.h saml21e17b.h saml21e18b.h saml21g16b.h saml21g17b.h saml21g18b.h saml21j16b.h saml21j17b.h saml21j18b.h
  group src/ASF/sam0/utils/cmsis/saml21/include_b/component
    ../../src/ASF/sam0/utils/cmsis/saml21/include_b/component/: ac.h adc.h aes.h ccl.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h mclk.h mtb.h nvmctrl.h opamp.h osc32kctrl.h oscctrl.h pac.h pm.h port.h rstc.h rtc.h sercom.h supc.h tal.h tc.h tcc.h trng.h usb.h wdt.h
  group src/ASF/sam0/utils/cmsis/saml21/include_b/instance
    ../../src/ASF/sam0/utils/cmsis/saml21/include_b/instance/: ac.h adc.h aes.h ccl.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h mclk.h mtb.h nvmctrl.h opamp.h osc32kctrl.h oscctrl.h pac.h pm.h port.h rstc.h rtc.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h supc.h tal.h tc0.h tc1.h tc2.h tc3.h tc4.h tcc0.h tcc1.h tcc2.h trng.h usb.h wdt.h
  group src/ASF/sam0/utils/cmsis/saml21/include_b/pio
    ../../src/ASF/sam0/utils/cmsis/saml21/include_b/pio/: saml21e15b.h saml21e16b.h saml21e17b.h saml21e18b.h saml21g16b.h saml21g17b.h saml21g18b.h saml21j16b.h saml21j17b.h saml21j18b.h
  group src/ASF/sam0/utils/cmsis/saml21/source
    ../../src/ASF/sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group src/ASF/sam0/utils/cmsis/saml21/source/iar
    ../../src/ASF/sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group src/ASF/sam0/utils/header_files
    ../../src/ASF/sam0/utils/header_files/: io.h
  group src/ASF/sam0/utils/preprocessor
    ../../src/ASF/sam0/utils/preprocessor/: mrecursion.h mrepeat.h preprocessor.h stringz.h tpaste.h
  group src/ASF/thirdparty/CMSIS/Include
    ../../src/ASF/thirdparty/CMSIS/Include/: arm_math.h core_cm0plus.h core_cmFunc.h core_cmInstr.h
  group src/ASF/thirdparty/freertos/freertos-9.0.0/Source
    ../../src/ASF/thirdparty/freertos/freertos-9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group src/ASF/thirdparty/freertos/freertos-9.0.0/Source/include
    ../../src/ASF/thirdparty/freertos/freertos-9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group src/ASF/thirdparty/freertos/freertos-9.0.0/Source/portable/IAR
    ../../src/ASF/thirdparty/freertos/freertos-9.0.0/Source/portable/IAR/ARM_CM0/: port_freeRTOS.c portasm.s portmacro.h
  group src/ASF/thirdparty/freertos/freertos-9.0.0/Source/portable/MemMang
    ../../src/ASF/thirdparty/freertos/freertos-9.0.0/Source/portable/MemMang/: heap_4.c
  group src/Config
    ../../src/Config/: conf_board.h conf_clocks.h conf_dma.h conf_extint.h conf_spi.h FreeRTOSConfig.h
  group systems
    ../../systems/: ios_thread.h os_wrapper.cpp os_wrapper.h singleton.h SystemsHeaders.h
