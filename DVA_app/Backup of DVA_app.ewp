# IAR project Backup of DVA_app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: __SAML21E18B__
  ICCARM.CCIncludePath2: ; config; hal\include; hal\utils\include; hpl\core; hpl\dmac; hpl\gclk; hpl\mclk; hpl\osc32kctrl; hpl\oscctrl; hpl\pm; hpl\port; hpl\sercom; hri; ; CMSIS\Include; saml21b\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __SAML21E18B__
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: DVA_app.out
  ILINK.IlinkIcfFile: saml21b\iar\iar\saml21e18b_flash.icf
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __SAML21E18B__
  ICCARM.CCOptLevel: 3
  group (top)
    ./: iar-project-connection.ipcf
  group src
    ./: atmel_start.c atmel_start.h atmel_start_pins.h main.c
  group src/CMSIS/Include
    CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group src/config
    config/: hpl_dmac_v222_config.h hpl_gclk2_v111_config.h hpl_mclk_v101_config.h hpl_osc32kctrl_v110_config.h hpl_oscctrl_v110_config.h hpl_sercom_v200_config.h peripheral_gclk_config.h
  group src/hal/include
    hal/include/: hal_atomic.h hal_delay.h hal_gpio.h hal_init.h hal_io.h hal_sleep.h hal_spi_m_sync.h hpl_core.h hpl_delay.h hpl_dma.h hpl_gpio.h hpl_i2c_m_async.h hpl_i2c_m_sync.h hpl_i2c_s_async.h hpl_i2c_s_sync.h hpl_init.h hpl_irq.h hpl_missing_features.h hpl_reset.h hpl_sleep.h hpl_spi.h hpl_spi_async.h hpl_spi_m_async.h hpl_spi_m_sync.h hpl_spi_s_async.h hpl_spi_s_sync.h hpl_spi_sync.h hpl_usart.h hpl_usart_async.h hpl_usart_sync.h
  group src/hal/src
    hal/src/: hal_atomic.c hal_delay.c hal_gpio.c hal_init.c hal_io.c hal_sleep.c hal_spi_m_sync.c
  group src/hal/utils/include
    hal/utils/include/: compiler.h err_codes.h events.h parts.h utils.h utils_assert.h utils_event.h utils_increment_macro.h utils_list.h utils_repeat_macro.h
  group src/hal/utils/src
    hal/utils/src/: utils_assert.c utils_event.c utils_list.c
  group src/hpl/core
    hpl/core/: hpl_core_m0plus_base.c hpl_core_port.h hpl_init.c
  group src/hpl/dmac
    hpl/dmac/: hpl_dmac_v222.c
  group src/hpl/gclk
    hpl/gclk/: hpl_gclk2_v111.c hpl_gclk2_v111_base.inc
  group src/hpl/mclk
    hpl/mclk/: hpl_mclk_v101.c
  group src/hpl/osc32kctrl
    hpl/osc32kctrl/: hpl_osc32kctrl_v110.c hpl_osc32kctrl_v110_base.inc
  group src/hpl/oscctrl
    hpl/oscctrl/: hpl_oscctrl_v110.c
  group src/hpl/pm
    hpl/pm/: hpl_pm2_v102.c
  group src/hpl/port
    hpl/port/: hpl_port_v201.c
  group src/hpl/sercom
    hpl/sercom/: hpl_sercom_v220.c
  group src/hri
    hri/: hri_dmac_v222.h hri_gclk2_v111.h hri_mclk_v101.h hri_nvmctrl_v302.h hri_osc32kctrl_v110.h hri_oscctrl_v110.h hri_pm2_v102.h hri_port_v201.h hri_sercom_v220.h
  group src/saml21b/iar
    saml21b/iar/: system_saml21.c
  group src/saml21b/iar/iar
    saml21b/iar/iar/: startup_saml21.c
  group src/saml21b/include
    saml21b/include/: component-version.h sam.h saml21.h saml21e15b.h saml21e16b.h saml21e17b.h saml21e18b.h saml21g16b.h saml21g17b.h saml21g18b.h saml21j16b.h saml21j17b.h saml21j18b.h saml21j18bu.h system_saml21.h
  group src/saml21b/include/component
    saml21b/include/component/: ac.h adc.h aes.h ccl.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h mclk.h mtb.h nvmctrl.h opamp.h osc32kctrl.h oscctrl.h pac.h pm.h port.h rstc.h rtc.h sercom.h supc.h tal.h tc.h tcc.h trng.h usb.h wdt.h
  group src/saml21b/include/instance
    saml21b/include/instance/: ac.h adc.h aes.h ccl.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h mclk.h mtb.h nvmctrl.h opamp.h osc32kctrl.h oscctrl.h pac.h pm.h port.h rstc.h rtc.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h supc.h tal.h tc0.h tc1.h tc2.h tc3.h tc4.h tcc0.h tcc1.h tcc2.h trng.h usb.h wdt.h
  group src/saml21b/include/pio
    saml21b/include/pio/: saml21e15b.h saml21e16b.h saml21e17b.h saml21e18b.h saml21g16b.h saml21g17b.h saml21g18b.h saml21j16b.h saml21j17b.h saml21j18b.h saml21j18bu.h
